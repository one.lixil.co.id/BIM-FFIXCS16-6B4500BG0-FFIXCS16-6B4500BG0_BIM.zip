Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-11-10T00:13:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Alternate UI 19.0.0.405
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 10 00:13:49 2022 * Host: DESKTOP-6FF1F60 * Database: C:\Users\Artec89\AppData\Local\Temp\{84F8FF5E-966B-4639-952E-3D31A3BC3FAE}\ifc * Database version: 5507 * Database creation date: Thu Nov 10 00:13:48 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 10 00:13:49 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 10 00:13:49 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: Free standing mixer, FFIXCS16-6B4500BG0_REVIT:Free standing mixer:370465
In: Level 1
Material: Zink
Pset_DistributionFlowElementCommon - Reference: Free standing mixer
